<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32-mod2.9-hw.ewp</path>
  </project>
  <batchBuild />
</workspace>
